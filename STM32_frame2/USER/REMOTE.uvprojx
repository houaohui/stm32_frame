# Keil uVision project REMOTE.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: REMOTE +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE;..\game\Hopper;..\HARDWARE\PWM;..\lib\meun;..\lib\oledlib;..\lib\imu;..\lib\filter;..\lib\millis;..\HARDWARE\ENCODER;..\HARDWARE\ADC;..\lib\pid;..\lib\uart2_recive;..\lib\imu\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c myconfig.h myinclude.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c key_ch455_iic.c
    ../HARDWARE/: timer.c timer.h
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
  group lib/oledlib
    ../lib/oledlib/: oled_basic.c oled_bmp.c oled_buffer.c oled_color.c oled_config.c oled_debug.c oled_draw.c oled_draw_ex_example.c oled_driver.c oled_font.c test.c
  group lib/meun
    ../lib/meun/: func.c gui.c menu.c
  group lib/millis
    ../lib/millis/: millis.c millis.h
  group lib/imu
    ../lib/imu/: lqax.c lqax.h posture.c posture.h softiic.c softiic.h
  group lib/filter
    ../lib/filter/: filter.c filter.h
  group lib/pid
    ../lib/pid/: controller.c controller.h pid.c pid.h
  group lib/uart2
    ../lib/uart2_recive/: usart2.c
